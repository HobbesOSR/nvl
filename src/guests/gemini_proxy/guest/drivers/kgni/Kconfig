## src/guests/gemini_proxy/guest/drivers/kgni/Kconfig
```kconfig
menuconfig KGNI
	tristate "Fake KGNI support"
	depends on PCI 
	---help---
	  gemini in Guest Environment. 
```
